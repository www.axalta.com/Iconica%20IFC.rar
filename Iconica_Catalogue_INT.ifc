Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcBuildingElementProxy: Superdurable Architectural SD Matt FINE PEARL, Axalta Surfaces:Superdurable Architectural SD Matt FINE PEARL:209252
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C9034020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt FINE PEARL
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt FINE PEARL; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt FINE PEARL; Typ: Axalta Surfaces: Superdurable Architectural SD Matt FINE PEARL; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt FINE PEARL

# IfcBuildingElementProxy: Superdurable Architectural SD Matt FRESH MOSS, Axalta Surfaces:Superdurable Architectural SD Matt FRESH MOSS:209253
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Fresh Moss
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt FRESH MOSS; Typname: Superdurable Architectural SD Matt FRESH MOSS
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Fresh Moss
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C6010020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt FRESH MOSS
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt FRESH MOSS; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt FRESH MOSS; Typ: Axalta Surfaces: Superdurable Architectural SD Matt FRESH MOSS; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt FRESH MOSS

# IfcBuildingElementProxy: Superdurable Architectural SD Matt GREEN CHLOROPHYLL, Axalta Surfaces:Superdurable Architectural SD Matt GREEN CHLOROPHYLL:209254
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Green Chlorophyll
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt GREEN CHLOROPHYLL; Typname: Superdurable Architectural SD Matt GREEN CHLOROPHYLL
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Green Chlorophyll
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C6009020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt GREEN CHLOROPHYLL
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt GREEN CHLOROPHYLL; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt GREEN CHLOROPHYLL; Typ: Axalta Surfaces: Superdurable Architectural SD Matt GREEN CHLOROPHYLL; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt GREEN CHLOROPHYLL

# IfcBuildingElementProxy: Superdurable Architectural SD Matt GREY GOLD, Axalta Surfaces:Superdurable Architectural SD Matt GREY GOLD:209255
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Grey Gold
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt GREY GOLD; Typname: Superdurable Architectural SD Matt GREY GOLD
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Grey Gold
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C7031020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt GREY GOLD
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt GREY GOLD; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt GREY GOLD; Typ: Axalta Surfaces: Superdurable Architectural SD Matt GREY GOLD; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt GREY GOLD

# IfcBuildingElementProxy: Superdurable Architectural SD Matt GROOVY RED, Axalta Surfaces:Superdurable Architectural SD Matt GROOVY RED:209256
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Groovy Red
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt GROOVY RED; Typname: Superdurable Architectural SD Matt GROOVY RED
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Groovy Red
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C3013020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt GROOVY RED
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt GROOVY RED; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt GROOVY RED; Typ: Axalta Surfaces: Superdurable Architectural SD Matt GROOVY RED; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt GROOVY RED

# IfcBuildingElementProxy: Superdurable Architectural SD Matt INTENSE CARBON, Axalta Surfaces:Superdurable Architectural SD Matt INTENSE CARBON:209306
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Intense Carbon
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt INTENSE CARBON; Typname: Superdurable Architectural SD Matt INTENSE CARBON
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Intense Carbon
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C4014020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt INTENSE CARBON
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt INTENSE CARBON; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt INTENSE CARBON; Typ: Axalta Surfaces: Superdurable Architectural SD Matt INTENSE CARBON; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt INTENSE CARBON

# IfcBuildingElementProxy: Superdurable Architectural SD Matt NOBLE BRONZE, Axalta Surfaces:Superdurable Architectural SD Matt NOBLE BRONZE:209307
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Noble Bronze
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt NOBLE BRONZE; Typname: Superdurable Architectural SD Matt NOBLE BRONZE
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Noble Bronze
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C8039020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt NOBLE BRONZE
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt NOBLE BRONZE; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt NOBLE BRONZE; Typ: Axalta Surfaces: Superdurable Architectural SD Matt NOBLE BRONZE; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt NOBLE BRONZE

# IfcBuildingElementProxy: Superdurable Architectural SD Matt NORDIC LICHEN, Axalta Surfaces:Superdurable Architectural SD Matt NORDIC LICHEN:209319
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Nordic Lichen
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt NORDIC LICHEN; Typname: Superdurable Architectural SD Matt NORDIC LICHEN
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Nordic Lichen
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C5008020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt NORDIC LICHEN
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt NORDIC LICHEN; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt NORDIC LICHEN; Typ: Axalta Surfaces: Superdurable Architectural SD Matt NORDIC LICHEN; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt NORDIC LICHEN

# IfcBuildingElementProxy: Superdurable Architectural SD Matt ORIGINAL PLATINIUM, Axalta Surfaces:Superdurable Architectural SD Matt ORIGINAL PLATINIUM:209308
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Original Platinum
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt ORIGINAL PLATINIUM; Typname: Superdurable Architectural SD Matt ORIGINAL PLATINIUM
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Original Platinum
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C7037020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt ORIGINAL PLATINIUM
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt ORIGINAL PLATINIUM; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt ORIGINAL PLATINIUM; Typ: Axalta Surfaces: Superdurable Architectural SD Matt ORIGINAL PLATINIUM; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt ORIGINAL PLATINIUM

# IfcBuildingElementProxy: Superdurable Architectural SD Matt SILVER DREAM, Axalta Surfaces:Superdurable Architectural SD Matt SILVER DREAM:209309
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Silver Dream
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt SILVER DREAM; Typname: Superdurable Architectural SD Matt SILVER DREAM
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Silver Dream
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C7036020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt SILVER DREAM
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt SILVER DREAM; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt SILVER DREAM; Typ: Axalta Surfaces: Superdurable Architectural SD Matt SILVER DREAM; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt SILVER DREAM

# IfcBuildingElementProxy: Superdurable Architectural SD Matt SIMPLY COPPER, Axalta Surfaces:Superdurable Architectural SD Matt SIMPLY COPPER:209310
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Simply Copper
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt SIMPLY COPPER; Typname: Superdurable Architectural SD Matt SIMPLY COPPER
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Simply Copper
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C2040020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt SIMPLY COPPER
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt SIMPLY COPPER; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt SIMPLY COPPER; Typ: Axalta Surfaces: Superdurable Architectural SD Matt SIMPLY COPPER; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt SIMPLY COPPER

# IfcBuildingElementProxy: Superdurable Architectural SD Matt SUNNY GOLD, Axalta Surfaces:Superdurable Architectural SD Matt SUNNY GOLD:209311
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Sunny Gold
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt SUNNY GOLD; Typname: Superdurable Architectural SD Matt SUNNY GOLD
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Sunny Gold
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C1032020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt SUNNY GOLD
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt SUNNY GOLD; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt SUNNY GOLD; Typ: Axalta Surfaces: Superdurable Architectural SD Matt SUNNY GOLD; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt SUNNY GOLD

# IfcBuildingElementProxy: Superdurable Architectural SD Matt URBAN CEMENT, Axalta Surfaces:Superdurable Architectural SD Matt URBAN CEMENT:209312
In: Level 1
Type - Material: Alesta SD-SuperDurable-Urban Cement
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt URBAN CEMENT; Typname: Superdurable Architectural SD Matt URBAN CEMENT
Type - Materialien und Oberflächen - Surface Color: Alesta SD-SuperDurable-Urban Cement
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C7018020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt URBAN CEMENT
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt URBAN CEMENT; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt URBAN CEMENT; Typ: Axalta Surfaces: Superdurable Architectural SD Matt URBAN CEMENT; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt URBAN CEMENT
