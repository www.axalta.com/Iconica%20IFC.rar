Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-04-03T14:49:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 03 14:49:27 2017 * Host: DESKTOP-Q1NIES2 * Database: C:\Users\GABORS~1\AppData\Local\Temp\{30D5CD3B-86AB-41C8-BD95-694F2EE8945A}\ifc * Database version: 5507 * Database creation date: Mon Apr 03 14:49:27 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 03 14:49:27 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 03 14:49:27 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Sonstige - Kategorie: Projektinformationen; Kundenname: Owner; Projektadresse: ## Street City, State Zip; Projektausgabedatum: Issue Date; Projektname: Project Name; Projektnummer: Project Number; Projektstatus: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Kundenname: Owner; Projektadresse: ## Street City, State Zip; Projektausgabedatum: Issue Date; Projektname: Project Name; Projektnummer: Project Number; Projektstatus: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Sonstige - Kategorie: Ebenen; Familienname: Ebene; Familie: Ebene: 8mm Head; Familie und Typ: Ebene: 8mm Head; Typ: Ebene: 8mm Head; Typ-ID: Ebene: 8mm Head
ID-Daten - Typname: 8mm Head; Gebäudegeschoss: yes; Name: Level 1; Tragwerk: no
Grafiken - Farbe: 0; Linienmuster: Center; Linienstärke: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten - Basishöhe: Projekt-Basispunkt; Ansicht: 0 mm
Abmessungen - Höhe für Berechnung: 0 mm

# IfcBuildingElementProxy: Modelltext:600mm Arial
In: Level 1
Text - Fett: no; Kursiv: no; Schriftart: Arial; Textgröße: 600 mm
Sonstige - Kategorie: Allgemeines Modell; Familienname: Modelltext; Familie: Modelltext: 600mm Arial; Familie und Typ: Modelltext: 600mm Arial; Typ: Modelltext: 600mm Arial; Typ-ID: Modelltext: 600mm Arial
ID-Daten - Typname: 600mm Arial; Unterkategorie: Allgemeines Modell
Pset_BuildingElementProxyCommon - Reference: 600mm Arial
Abhängigkeiten - Arbeitsebene: Ebene : Level 1
Abmessungen - Tiefe: 150 mm
Grafiken - Horizontale Ausrichtung: Links; Text: Axalta metal surfaces
Phasen - Phase erstellt: New Construction

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture AQUA SPLASH, Axalta Surfaces:Superdurable Architectural SD Fine Texture AQUA SPLASH:208123
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Aqua Splash
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture AQUA SPLASH; Typname: Superdurable Architectural SD Fine Texture AQUA SPLASH
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Aqua Splash
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Solid; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD130C5017020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture AQUA SPLASH
Abhängigkeiten - Basisbauteil: Ebene : Level 1; Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture AQUA SPLASH; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture AQUA SPLASH; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture AQUA SPLASH; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture AQUA SPLASH

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture ARTIC ICE, Axalta Surfaces:Superdurable Architectural SD Fine Texture ARTIC ICE:209627
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Artic Ice
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture ARTIC ICE; Typname: Superdurable Architectural SD Fine Texture ARTIC ICE
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Artic Ice
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C7002020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture ARTIC ICE
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture ARTIC ICE; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture ARTIC ICE; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture ARTIC ICE; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture ARTIC ICE

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture BEIGE LIMESTONE, Axalta Surfaces:Superdurable Architectural SD Fine Texture BEIGE LIMESTONE:209135
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Beige Limestone
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture BEIGE LIMESTONE; Typname: Superdurable Architectural SD Fine Texture BEIGE LIMESTONE
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Beige Limestone
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C1007020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture BEIGE LIMESTONE
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture BEIGE LIMESTONE; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture BEIGE LIMESTONE; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture BEIGE LIMESTONE; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture BEIGE LIMESTONE

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture BLUE WORKSHOP, Axalta Surfaces:Superdurable Architectural SD Fine Texture BLUE WORKSHOP:208389
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Blue workshop
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture BLUE WORKSHOP; Typname: Superdurable Architectural SD Fine Texture BLUE WORKSHOP
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Blue workshop
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C5029020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture BLUE WORKSHOP
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture BLUE WORKSHOP; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture BLUE WORKSHOP; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture BLUE WORKSHOP; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture BLUE WORKSHOP

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture BROWN SLATE, Axalta Surfaces:Superdurable Architectural SD Fine Texture BROWN SLATE:208392
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Brown Slate
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture BROWN SLATE; Typname: Superdurable Architectural SD Fine Texture BROWN SLATE
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Brown Slate
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Solid; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD030C8004020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture BROWN SLATE
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1; Ebene: Ebene: Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture BROWN SLATE; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture BROWN SLATE; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture BROWN SLATE; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture BROWN SLATE

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture CAST IRON, Axalta Surfaces:Superdurable Architectural SD Fine Texture CAST IRON:208395
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Cast Iron
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture CAST IRON; Typname: Superdurable Architectural SD Fine Texture CAST IRON
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Cast Iron
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C4900520; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture CAST IRON
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture CAST IRON; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture CAST IRON; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture CAST IRON; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture CAST IRON

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture CITY TERRACOTTA, Axalta Surfaces:Superdurable Architectural SD Fine Texture CITY TERRACOTTA:208398
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-City Terracotta
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture CITY TERRACOTTA; Typname: Superdurable Architectural SD Fine Texture CITY TERRACOTTA
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-City Terracotta
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C8021020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture CITY TERRACOTTA
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture CITY TERRACOTTA; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture CITY TERRACOTTA; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture CITY TERRACOTTA; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture CITY TERRACOTTA

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture EARTH CLAY, Axalta Surfaces:Superdurable Architectural SD Fine Texture EARTH CLAY:208401
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Earth Clay
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture EARTH CLAY; Typname: Superdurable Architectural SD Fine Texture EARTH CLAY
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Earth Clay
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C8005020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture EARTH CLAY
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture EARTH CLAY; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture EARTH CLAY; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture EARTH CLAY; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture EARTH CLAY

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture FA'BRICK, Axalta Surfaces:Superdurable Architectural SD Fine Texture FA'BRICK:209158
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-FaBrick
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture FA'BRICK; Typname: Superdurable Architectural SD Fine Texture FA'BRICK
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-FaBrick
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C8022020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture FA'BRICK
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture FA'BRICK; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture FA'BRICK; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture FA'BRICK; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture FA'BRICK

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture GOLD SUPREME, Axalta Surfaces:Superdurable Architectural SD Fine Texture GOLD SUPREME:209159
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Gold Supreme
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture GOLD SUPREME; Typname: Superdurable Architectural SD Fine Texture GOLD SUPREME
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Gold Supreme
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C1033020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture GOLD SUPREME
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture GOLD SUPREME; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture GOLD SUPREME; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture GOLD SUPREME; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture GOLD SUPREME

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture GRANIT NATURE “9007”, Axalta Surfaces:Superdurable Architectural SD Fine Texture GRANIT NATURE “9007”:209171
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Granit Nature "9007"
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture GRANIT NATURE “9007”; Typname: Superdurable Architectural SD Fine Texture GRANIT NATURE “9007”
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Granit Nature "9007"
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C7900720; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture GRANIT NATURE “9007”
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture GRANIT NATURE “9007”; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture GRANIT NATURE “9007”; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture GRANIT NATURE “9007”; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture GRANIT NATURE “9007”

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture GREEN FACTORY, Axalta Surfaces:Superdurable Architectural SD Fine Texture GREEN FACTORY:209160
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Green Factory
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture GREEN FACTORY; Typname: Superdurable Architectural SD Fine Texture GREEN FACTORY
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Green Factory
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C6030020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture GREEN FACTORY
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture GREEN FACTORY; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture GREEN FACTORY; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture GREEN FACTORY; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture GREEN FACTORY

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture KINETIC TANGERINE, Axalta Surfaces:Superdurable Architectural SD Fine Texture KINETIC TANGERINE:209161
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture KINETIC TANGERINE; Typname: Superdurable Architectural SD Fine Texture KINETIC TANGERINE
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Solid; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD130C2011020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture KINETIC TANGERINE
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture KINETIC TANGERINE; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture KINETIC TANGERINE; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture KINETIC TANGERINE; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture KINETIC TANGERINE

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture METALLIC ASPHALT, Axalta Surfaces:Superdurable Architectural SD Fine Texture METALLIC ASPHALT:209162
In: Level 1
Type - Material: Alesta SD-SuperDurable-Metallic Asphalt
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture METALLIC ASPHALT; Typname: Superdurable Architectural SD Fine Texture METALLIC ASPHALT
Type - Materialien und Oberflächen - Surface Color: Alesta SD-SuperDurable-Metallic Asphalt
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C4020020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture METALLIC ASPHALT
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture METALLIC ASPHALT; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture METALLIC ASPHALT; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture METALLIC ASPHALT; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture METALLIC ASPHALT

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture MODERN KHAKI, Axalta Surfaces:Superdurable Architectural SD Fine Texture MODERN KHAKI:209163
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Modern Khaki
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture MODERN KHAKI; Typname: Superdurable Architectural SD Fine Texture MODERN KHAKI
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Modern Khaki
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Solid; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD130C6026020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture MODERN KHAKI
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture MODERN KHAKI; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture MODERN KHAKI; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture MODERN KHAKI; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture MODERN KHAKI

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture PRECIOUS SAND, Axalta Surfaces:Superdurable Architectural SD Fine Texture PRECIOUS SAND:209164
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Precious Sand
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture PRECIOUS SAND; Typname: Superdurable Architectural SD Fine Texture PRECIOUS SAND
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Precious Sand
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C8006020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture PRECIOUS SAND
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture PRECIOUS SAND; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture PRECIOUS SAND; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture PRECIOUS SAND; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture PRECIOUS SAND

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture SENERE SNOW, Axalta Surfaces:Superdurable Architectural SD Fine Texture SENERE SNOW:209199
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Senere Snow
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture SENERE SNOW; Typname: Superdurable Architectural SD Fine Texture SENERE SNOW
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Senere Snow
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C9001020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture SENERE SNOW
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture SENERE SNOW; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture SENERE SNOW; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture SENERE SNOW; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture SENERE SNOW

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture SMOKED STEEL, Axalta Surfaces:Superdurable Architectural SD Fine Texture SMOKED STEEL:209200
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Smoked Steel
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture SMOKED STEEL; Typname: Superdurable Architectural SD Fine Texture SMOKED STEEL
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Smoked Steel
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C8025020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture SMOKED STEEL
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture SMOKED STEEL; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture SMOKED STEEL; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture SMOKED STEEL; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture SMOKED STEEL

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture TIMELESS RUST, Axalta Surfaces:Superdurable Architectural SD Fine Texture TIMELESS RUST:209212
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Timeless Rust
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture TIMELESS RUST; Typname: Superdurable Architectural SD Fine Texture TIMELESS RUST
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Timeless Rust
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Speckled; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD034C8023020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture TIMELESS RUST
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture TIMELESS RUST; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture TIMELESS RUST; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture TIMELESS RUST; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture TIMELESS RUST

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture VERDIGRIS, Axalta Surfaces:Superdurable Architectural SD Fine Texture VERDIGRIS:209201
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Verdigris
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture VERDIGRIS; Typname: Superdurable Architectural SD Fine Texture VERDIGRIS
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Verdigris
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C6027020; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture VERDIGRIS
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture VERDIGRIS; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture VERDIGRIS; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture VERDIGRIS; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture VERDIGRIS

# IfcBuildingElementProxy: Superdurable Architectural SD Fine Texture VINTAGE RED, Axalta Surfaces:Superdurable Architectural SD Fine Texture VINTAGE RED:209202
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Vintage Red
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Fine Texture VINTAGE RED; Typname: Superdurable Architectural SD Fine Texture VINTAGE RED
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Vintage Red
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD031C3300520; Series: SD Fine Texture; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Fine Texture VINTAGE RED
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Fine Texture VINTAGE RED; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture VINTAGE RED; Typ: Axalta Surfaces: Superdurable Architectural SD Fine Texture VINTAGE RED; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Fine Texture VINTAGE RED

# IfcBuildingElementProxy: Superdurable Architectural SD Gloss TECHNO BLACK, Axalta Surfaces:Superdurable Architectural SD Gloss TECHNO BLACK:209203
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Techno Black
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Gloss TECHNO BLACK; Typname: Superdurable Architectural SD Gloss TECHNO BLACK
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Techno Black
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD801C4038020; Series: SD Gloss; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Gloss TECHNO BLACK
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Gloss TECHNO BLACK; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Gloss TECHNO BLACK; Typ: Axalta Surfaces: Superdurable Architectural SD Gloss TECHNO BLACK; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Gloss TECHNO BLACK

# IfcBuildingElementProxy: Superdurable Architectural SD Matt ANODISED SILVER, Axalta Surfaces:Superdurable Architectural SD Matt ANODISED SILVER:209204
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Anodised Silver
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt ANODISED SILVER; Typname: Superdurable Architectural SD Matt ANODISED SILVER
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Anodised Silver
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD201C7035020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt ANODISED SILVER
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt ANODISED SILVER; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt ANODISED SILVER; Typ: Axalta Surfaces: Superdurable Architectural SD Matt ANODISED SILVER; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt ANODISED SILVER

# IfcBuildingElementProxy: Superdurable Architectural SD Matt CONCRETE TOUCH 9006, Axalta Surfaces:Superdurable Architectural SD Matt CONCRETE TOUCH 9006:209205
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Concrete Touch "9006"
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt CONCRETE TOUCH 9006; Typname: Superdurable Architectural SD Matt CONCRETE TOUCH 9006
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Concrete Touch "9006"
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C7900621; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt CONCRETE TOUCH 9006
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt CONCRETE TOUCH 9006; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt CONCRETE TOUCH 9006; Typ: Axalta Surfaces: Superdurable Architectural SD Matt CONCRETE TOUCH 9006; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt CONCRETE TOUCH 9006

# IfcBuildingElementProxy: Superdurable Architectural SD Matt DENIM EFFECT, Axalta Surfaces:Superdurable Architectural SD Matt DENIM EFFECT:209250
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Denim Effect
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt DENIM EFFECT; Typname: Superdurable Architectural SD Matt DENIM EFFECT
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Denim Effect
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C5015020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt DENIM EFFECT
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt DENIM EFFECT; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt DENIM EFFECT; Typ: Axalta Surfaces: Superdurable Architectural SD Matt DENIM EFFECT; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt DENIM EFFECT

# IfcBuildingElementProxy: Superdurable Architectural SD Matt DIGITAL RED, Axalta Surfaces:Superdurable Architectural SD Matt DIGITAL RED:209251
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Digital Red
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt DIGITAL RED; Typname: Superdurable Architectural SD Matt DIGITAL RED
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Digital Red
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C3012020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt DIGITAL RED
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt DIGITAL RED; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt DIGITAL RED; Typ: Axalta Surfaces: Superdurable Architectural SD Matt DIGITAL RED; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt DIGITAL RED

# IfcBuildingElementProxy: Superdurable Architectural SD Matt ELECTRIC DREAM, Axalta Surfaces:Superdurable Architectural SD Matt ELECTRIC DREAM:209263
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Electric dream
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt ELECTRIC DREAM; Typname: Superdurable Architectural SD Matt ELECTRIC DREAM
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Electric dream
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
Type - Text - Class: Surfaces; Model: Bonded Metallic; Product available in: ACE; Product Contact Email: powdersales@axaltacs.com; Product Contact Number: +44 13 25 34 70 00; Product URL: http//www.axaltacs.com/gb/iconica; Reference Code: SD301C5016020; Series: SD Matt; Technical Information: On aluminium steel and hot-dip galvanized steel both chemical pre-treatment and mechanical surface preparation are compatible with Alesta® SD. Surface preparation should be chosen according to type of substrate and required performance. The suitability of the surface preparation should be tested by the coater beforehand using appropriate test methods.
Pset_BuildingElementProxyCommon - Reference: Superdurable Architectural SD Matt ELECTRIC DREAM
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces: Superdurable Architectural SD Matt ELECTRIC DREAM; Familie und Typ: Axalta Surfaces: Superdurable Architectural SD Matt ELECTRIC DREAM; Typ: Axalta Surfaces: Superdurable Architectural SD Matt ELECTRIC DREAM; Typ-ID: Axalta Surfaces: Superdurable Architectural SD Matt ELECTRIC DREAM

# IfcBuildingElementProxy: Superdurable Architectural SD Matt FINE PEARL, Axalta Surfaces:Superdurable Architectural SD Matt FINE PEARL:209252
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Fine Pearl
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superior weather resistant polyester powder coating combining a wide range of decorative aspects with excellent durability
Type - ID-Daten - (Type) Name: Matt FINE PEARL; Typname: Superdurable Architectural SD Matt FINE PEARL
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Fine Pearl
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces
