Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcBuildingElementProxy: Alesta SD-SuperDurable-Metallic Asphalt, Axalta Surfaces_ES:Alesta SD-SuperDurable-Metallic Asphalt:209253
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-SuperDurable-Metallic Asphalt; Familie und Typ: Axalta Surfaces_ES: Alesta SD-SuperDurable-Metallic Asphalt; Typ: Axalta Surfaces_ES: Alesta SD-SuperDurable-Metallic Asphalt; Typ-ID: Axalta Surfaces_ES: Alesta SD-SuperDurable-Metallic Asphalt

# IfcBuildingElementProxy: Alesta SD-SuperDurable-Urban Cement, Axalta Surfaces_ES:Alesta SD-SuperDurable-Urban Cement:209254
In: Level 1
Type - Material: Alesta SD-SuperDurable-Urban Cement
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt URBAN CEMENT; Hersteller: Axalta Coating Systems; Product Code: SD301C7018020; Typname: Alesta SD-SuperDurable-Urban Cement; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-SuperDurable-Urban Cement
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C7018020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C7018020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-SuperDurable-Urban Cement
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-SuperDurable-Urban Cement; Familie und Typ: Axalta Surfaces_ES: Alesta SD-SuperDurable-Urban Cement; Typ: Axalta Surfaces_ES: Alesta SD-SuperDurable-Urban Cement; Typ-ID: Axalta Surfaces_ES: Alesta SD-SuperDurable-Urban Cement

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Anodised Silver, Axalta Surfaces_ES:Alesta SD-TECHNO PRECIOUS-Anodised Silver:209255
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Anodised Silver
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt ANODISED SILVER; Hersteller: Axalta Coating Systems; Product Code: SD201C7035020; Typname: Alesta SD-TECHNO PRECIOUS-Anodised Silver; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Anodised Silver
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD201C7035020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD201C7035020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Anodised Silver
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Anodised Silver; Familie und Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Anodised Silver; Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Anodised Silver; Typ-ID: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Anodised Silver

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Fine Pearl, Axalta Surfaces_ES:Alesta SD-TECHNO PRECIOUS-Fine Pearl:209256
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Fine Pearl
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt FINE PEARL; Hersteller: Axalta Coating Systems; Product Code: SD301C9034020; Typname: Alesta SD-TECHNO PRECIOUS-Fine Pearl; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Fine Pearl
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C9034020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C9034020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Fine Pearl
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Fine Pearl; Familie und Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Fine Pearl; Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Fine Pearl; Typ-ID: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Fine Pearl

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Gold Supreme, Axalta Surfaces_ES:Alesta SD-TECHNO PRECIOUS-Gold Supreme:209306
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Gold Supreme
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture GOLD SUPREME; Hersteller: Axalta Coating Systems; Product Code: SD031C1033020; Typname: Alesta SD-TECHNO PRECIOUS-Gold Supreme; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Gold Supreme
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C1033020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C1033020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Gold Supreme
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Gold Supreme; Familie und Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Gold Supreme; Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Gold Supreme; Typ-ID: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Gold Supreme

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Grey Gold, Axalta Surfaces_ES:Alesta SD-TECHNO PRECIOUS-Grey Gold:209307
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Grey Gold
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt GREY GOLD; Hersteller: Axalta Coating Systems; Product Code: SD301C7031020; Typname: Alesta SD-TECHNO PRECIOUS-Grey Gold; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Grey Gold
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C7031020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C7031020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Grey Gold
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Grey Gold; Familie und Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Grey Gold; Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Grey Gold; Typ-ID: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Grey Gold

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Noble Bronze, Axalta Surfaces_ES:Alesta SD-TECHNO PRECIOUS-Noble Bronze:209319
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Noble Bronze
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt NOBLE BRONZE; Hersteller: Axalta Coating Systems; Product Code: SD301C8039020; Typname: Alesta SD-TECHNO PRECIOUS-Noble Bronze; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Noble Bronze
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C8039020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C8039020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Noble Bronze
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Noble Bronze; Familie und Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Noble Bronze; Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Noble Bronze; Typ-ID: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Noble Bronze

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Original Platinum, Axalta Surfaces_ES:Alesta SD-TECHNO PRECIOUS-Original Platinum:209308
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Original Platinum
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt ORIGINAL PLATINIUM; Hersteller: Axalta Coating Systems; Product Code: SD301C7037020; Typname: Alesta SD-TECHNO PRECIOUS-Original Platinum; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Original Platinum
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C7037020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C7037020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Original Platinum
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Original Platinum; Familie und Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Original Platinum; Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Original Platinum; Typ-ID: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Original Platinum

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Silver Dream, Axalta Surfaces_ES:Alesta SD-TECHNO PRECIOUS-Silver Dream:209309
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Silver Dream
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt SILVER DREAM; Hersteller: Axalta Coating Systems; Product Code: SD301C7036020; Typname: Alesta SD-TECHNO PRECIOUS-Silver Dream; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Silver Dream
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C7036020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C7036020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Silver Dream
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Silver Dream; Familie und Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Silver Dream; Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Silver Dream; Typ-ID: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Silver Dream

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Simply Copper, Axalta Surfaces_ES:Alesta SD-TECHNO PRECIOUS-Simply Copper:209310
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Simply Copper
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt SIMPLY COPPER; Hersteller: Axalta Coating Systems; Product Code: SD301C2040020; Typname: Alesta SD-TECHNO PRECIOUS-Simply Copper; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Simply Copper
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C2040020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C2040020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Simply Copper
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Simply Copper; Familie und Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Simply Copper; Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Simply Copper; Typ-ID: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Simply Copper

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Sunny Gold, Axalta Surfaces_ES:Alesta SD-TECHNO PRECIOUS-Sunny Gold:209311
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Sunny Gold
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt SUNNY GOLD; Hersteller: Axalta Coating Systems; Product Code: SD301C1032020; Typname: Alesta SD-TECHNO PRECIOUS-Sunny Gold; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Sunny Gold
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C1032020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C1032020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Sunny Gold
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Sunny Gold; Familie und Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Sunny Gold; Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Sunny Gold; Typ-ID: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Sunny Gold

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Techno Black, Axalta Surfaces_ES:Alesta SD-TECHNO PRECIOUS-Techno Black:209312
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Techno Black
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Gloss TECHNO BLACK; Hersteller: Axalta Coating Systems; Product Code: SD801C4038020; Typname: Alesta SD-TECHNO PRECIOUS-Techno Black; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Techno Black
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Brillante Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD801C4038020; Series: SD Gloss; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD801C4038020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Techno Black
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Techno Black; Familie und Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Techno Black; Typ: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Techno Black; Typ-ID: Axalta Surfaces_ES: Alesta SD-TECHNO PRECIOUS-Techno Black

# IfcBuildingElementProxy: Modelltext:600mm Arial
In: Level 1
Text - Fett: no; Kursiv: no; Schriftart: Arial; Textgröße: 600 mm
Sonstige - Kategorie: Allgemeines Modell; Familienname: Modelltext; Familie: Modelltext: 600mm Arial; Familie und Typ: Modelltext: 600mm Arial; Typ: Modelltext: 600mm Arial; Typ-ID: Modelltext: 600mm Arial
ID-Daten - Typname: 600mm Arial; Unterkategorie: Allgemeines Modell
Pset_BuildingElementProxyCommon - Reference: 600mm Arial
Abhängigkeiten - Arbeitsebene: Ebene : Level 1
Abmessungen - Tiefe: 150 mm
Grafiken - Horizontale Ausrichtung: Links; Text: Axalta metal surfaces
Phasen - Phase erstellt: New Construction
