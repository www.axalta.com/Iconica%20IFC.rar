Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-04-03T14:44:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 03 14:44:28 2017 * Host: DESKTOP-Q1NIES2 * Database: C:\Users\GABORS~1\AppData\Local\Temp\{83B279D8-9C6E-49FB-81F1-2721CD14AC7B}\ifc * Database version: 5507 * Database creation date: Mon Apr 03 14:44:27 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 03 14:44:27 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 03 14:44:27 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Sonstige - Kategorie: Projektinformationen; Kundenname: Owner; Projektadresse: ## Street City, State Zip; Projektausgabedatum: Issue Date; Projektname: Project Name; Projektnummer: Project Number; Projektstatus: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Kundenname: Owner; Projektadresse: ## Street City, State Zip; Projektausgabedatum: Issue Date; Projektname: Project Name; Projektnummer: Project Number; Projektstatus: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Sonstige - Kategorie: Ebenen; Familienname: Ebene; Familie: Ebene: 8mm Head; Familie und Typ: Ebene: 8mm Head; Typ: Ebene: 8mm Head; Typ-ID: Ebene: 8mm Head
ID-Daten - Typname: 8mm Head; Gebäudegeschoss: yes; Name: Level 1; Tragwerk: no
Grafiken - Farbe: 0; Linienmuster: Center; Linienstärke: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten - Basishöhe: Projekt-Basispunkt; Ansicht: 0 mm
Abmessungen - Höhe für Berechnung: 0 mm

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-Blue workshop, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-Blue workshop:208123
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Blue workshop
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture BLUE WORKSHOP; Hersteller: Axalta Coating Systems; Product Code: SD031C5029020; Typname: Alesta SD-ARTY FUSION-Blue workshop; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Blue workshop
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C5029020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C5029020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-Blue workshop
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Basisbauteil: Ebene : Level 1; Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Blue workshop; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Blue workshop; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Blue workshop; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Blue workshop

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-Brown Slate, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-Brown Slate:209627
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Brown Slate
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture BROWN SLATE; Hersteller: Axalta Coating Systems; Product Code: SD030C8004020; Typname: Alesta SD-ARTY FUSION-Brown Slate; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Brown Slate
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD030C8004020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD030C8004020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-Brown Slate
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Brown Slate; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Brown Slate; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Brown Slate; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Brown Slate

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-Cast Iron, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-Cast Iron:209135
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Cast Iron
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture CAST IRON; Hersteller: Axalta Coating Systems; Product Code: SD031C4900520; Typname: Alesta SD-ARTY FUSION-Cast Iron; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Cast Iron
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C4900520; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C4900520
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-Cast Iron
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Cast Iron; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Cast Iron; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Cast Iron; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Cast Iron

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-City Terracotta, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-City Terracotta:208389
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-City Terracotta
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture CITY TERRACOTTA; Hersteller: Axalta Coating Systems; Product Code: SD031C8021020; Typname: Alesta SD-ARTY FUSION-City Terracotta; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-City Terracotta
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C8021020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C8021020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-City Terracotta
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-City Terracotta; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-City Terracotta; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-City Terracotta; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-City Terracotta

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-FaBrick, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-FaBrick:208392
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-FaBrick
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture FABRICK; Hersteller: Axalta Coating Systems; Product Code: SD031C8022020; Typname: Alesta SD-ARTY FUSION-FaBrick; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-FaBrick
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C8022020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C8022020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-FaBrick
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1; Ebene: Ebene: Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-FaBrick; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-FaBrick; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-FaBrick; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-FaBrick

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-Green Factory, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-Green Factory:208395
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Green Factory
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture GREEN FACTORY; Hersteller: Axalta Coating Systems; Product Code: SD031C6030020; Typname: Alesta SD-ARTY FUSION-Green Factory; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Green Factory
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C6030020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C6027020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-Green Factory
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Green Factory; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Green Factory; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Green Factory; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Green Factory

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-Modern Khaki, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-Modern Khaki:208398
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Modern Khaki
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture MODERN KHAKI; Hersteller: Axalta Coating Systems; Product Code: SD130C6026020; Typname: Alesta SD-ARTY FUSION-Modern Khaki; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Modern Khaki
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD130C6026020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD130C6026020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-Modern Khaki
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Modern Khaki; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Modern Khaki; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Modern Khaki; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Modern Khaki

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-Smoked Steel, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-Smoked Steel:208401
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Smoked Steel
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture SMOKED STEEL; Hersteller: Axalta Coating Systems; Product Code: SD031C8025020; Typname: Alesta SD-ARTY FUSION-Smoked Steel; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Smoked Steel
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C8025020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C8025020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-Smoked Steel
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Smoked Steel; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Smoked Steel; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Smoked Steel; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Smoked Steel

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-Timeless Rust, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-Timeless Rust:209158
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Timeless Rust
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture TIMELESS RUST; Hersteller: Axalta Coating Systems; Product Code: SD034C8023020; Typname: Alesta SD-ARTY FUSION-Timeless Rust; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Timeless Rust
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD034C8023020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD034C8023020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-Timeless Rust
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Timeless Rust; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Timeless Rust; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Timeless Rust; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Timeless Rust

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-Verdigris, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-Verdigris:209159
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Verdigris
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture VERDIGRIS; Hersteller: Axalta Coating Systems; Product Code: SD031C6027020; Typname: Alesta SD-ARTY FUSION-Verdigris; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Verdigris
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C6027020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C4020027
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-Verdigris
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Verdigris; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Verdigris; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Verdigris; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Verdigris

# IfcBuildingElementProxy: Alesta SD-ARTY FUSION-Vintage Red, Axalta Surfaces_ES:Alesta SD-ARTY FUSION-Vintage Red:209171
In: Level 1
Type - Material: Alesta SD-ARTY FUSION-Vintage Red
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture VINTAGE RED; Hersteller: Axalta Coating Systems; Product Code: SD031C3300520; Typname: Alesta SD-ARTY FUSION-Vintage Red; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ARTY FUSION-Vintage Red
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C3300520; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C3300520
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ARTY FUSION-Vintage Red
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Vintage Red; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Vintage Red; Typ: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Vintage Red; Typ-ID: Axalta Surfaces_ES: Alesta SD-ARTY FUSION-Vintage Red

# IfcBuildingElementProxy: Alesta SD-EDEN GARDEN-Artic Ice, Axalta Surfaces_ES:Alesta SD-EDEN GARDEN-Artic Ice:209160
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Artic Ice
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture ARTIC ICE; Hersteller: Axalta Coating Systems; Product Code: SD031C7002020; Typname: Alesta SD-EDEN GARDEN-Artic Ice; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Artic Ice
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C7002020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C7002020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-EDEN GARDEN-Artic Ice
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Artic Ice; Familie und Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Artic Ice; Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Artic Ice; Typ-ID: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Artic Ice

# IfcBuildingElementProxy: Alesta SD-EDEN GARDEN-Beige Limestone, Axalta Surfaces_ES:Alesta SD-EDEN GARDEN-Beige Limestone:209161
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Beige Limestone
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture BEIGE LIMESTONE; Hersteller: Axalta Coating Systems; Product Code: SD031C1007020; Typname: Alesta SD-EDEN GARDEN-Beige Limestone; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Beige Limestone
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C1007020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C1007020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-EDEN GARDEN-Beige Limestone
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Beige Limestone; Familie und Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Beige Limestone; Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Beige Limestone; Typ-ID: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Beige Limestone

# IfcBuildingElementProxy: Alesta SD-EDEN GARDEN-Earth Clay, Axalta Surfaces_ES:Alesta SD-EDEN GARDEN-Earth Clay:209162
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Earth Clay
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture EARTH CLAY; Hersteller: Axalta Coating Systems; Product Code: SD031C8005020; Typname: Alesta SD-EDEN GARDEN-Earth Clay; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Earth Clay
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C8005020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C8005020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-EDEN GARDEN-Earth Clay
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Earth Clay; Familie und Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Earth Clay; Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Earth Clay; Typ-ID: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Earth Clay

# IfcBuildingElementProxy: Alesta SD-EDEN GARDEN-Fresh Moss, Axalta Surfaces_ES:Alesta SD-EDEN GARDEN-Fresh Moss:209163
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Fresh Moss
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt FRESH MOSS; Hersteller: Axalta Coating Systems; Product Code: SD301C6010020; Typname: Alesta SD-EDEN GARDEN-Fresh Moss; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Fresh Moss
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C6010020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C6010020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-EDEN GARDEN-Fresh Moss
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Fresh Moss; Familie und Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Fresh Moss; Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Fresh Moss; Typ-ID: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Fresh Moss

# IfcBuildingElementProxy: Alesta SD-EDEN GARDEN-Granit Nature 9007, Axalta Surfaces_ES:Alesta SD-EDEN GARDEN-Granit Nature 9007:209164
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Granit Nature "9007"
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture GRANIT NATURE 9007; Hersteller: Axalta Coating Systems; Product Code: SD031C7900720; Typname: Alesta SD-EDEN GARDEN-Granit Nature 9007; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Granit Nature "9007"
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C7900720; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C7900720
Pset_BuildingElementProxyCommon - Reference: Alesta SD-EDEN GARDEN-Granit Nature 9007
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Granit Nature 9007; Familie und Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Granit Nature 9007; Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Granit Nature 9007; Typ-ID: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Granit Nature 9007

# IfcBuildingElementProxy: Alesta SD-EDEN GARDEN-Green Chlorophyll, Axalta Surfaces_ES:Alesta SD-EDEN GARDEN-Green Chlorophyll:209199
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Green Chlorophyll
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt GREEN CHLOROPHYLL; Hersteller: Axalta Coating Systems; Product Code: SD301C6009020; Typname: Alesta SD-EDEN GARDEN-Green Chlorophyll; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Green Chlorophyll
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C6009020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C6009020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-EDEN GARDEN-Green Chlorophyll
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Green Chlorophyll; Familie und Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Green Chlorophyll; Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Green Chlorophyll; Typ-ID: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Green Chlorophyll

# IfcBuildingElementProxy: Alesta SD-EDEN GARDEN-Nordic Lichen, Axalta Surfaces_ES:Alesta SD-EDEN GARDEN-Nordic Lichen:209200
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Nordic Lichen
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt NORDIC LICHEN; Hersteller: Axalta Coating Systems; Product Code: SD301C5008020; Typname: Alesta SD-EDEN GARDEN-Nordic Lichen; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Nordic Lichen
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C5008020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C5008020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-EDEN GARDEN-Nordic Lichen
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Nordic Lichen; Familie und Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Nordic Lichen; Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Nordic Lichen; Typ-ID: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Nordic Lichen

# IfcBuildingElementProxy: Alesta SD-EDEN GARDEN-Precious Sand, Axalta Surfaces_ES:Alesta SD-EDEN GARDEN-Precious Sand:209212
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Precious Sand
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture PRECIOUS SAND; Hersteller: Axalta Coating Systems; Product Code: SD031C8006020; Typname: Alesta SD-EDEN GARDEN-Precious Sand; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Precious Sand
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C8006020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C8006020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-EDEN GARDEN-Precious Sand
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Precious Sand; Familie und Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Precious Sand; Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Precious Sand; Typ-ID: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Precious Sand

# IfcBuildingElementProxy: Alesta SD-EDEN GARDEN-Senere Snow, Axalta Surfaces_ES:Alesta SD-EDEN GARDEN-Senere Snow:209201
In: Level 1
Type - Material: Alesta SD-EDEN GARDEN-Senere Snow
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture SENERE SNOW; Hersteller: Axalta Coating Systems; Product Code: SD031C9001020; Typname: Alesta SD-EDEN GARDEN-Senere Snow; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-EDEN GARDEN-Senere Snow
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C9001020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C9001020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-EDEN GARDEN-Senere Snow
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Senere Snow; Familie und Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Senere Snow; Typ: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Senere Snow; Typ-ID: Axalta Surfaces_ES: Alesta SD-EDEN GARDEN-Senere Snow

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Aqua Splash, Axalta Surfaces_ES:Alesta SD-ENERGY MANIFESTO-Aqua Splash:209202
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Aqua Splash
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture AQUA SPLASH; Hersteller: Axalta Coating Systems; Product Code: SD130C5017020; Typname: Alesta SD-ENERGY MANIFESTO-Aqua Splash; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Aqua Splash
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD130C5017020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD130C5017020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Aqua Splash
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Aqua Splash; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Aqua Splash; Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Aqua Splash; Typ-ID: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Aqua Splash

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Concrete Touch 9006, Axalta Surfaces_ES:Alesta SD-ENERGY MANIFESTO-Concrete Touch 9006:209203
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Concrete Touch "9006"
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt CONCRETE TOUCH 9006; Hersteller: Axalta Coating Systems; Product Code: SD301C7900621; Typname: Alesta SD-ENERGY MANIFESTO-Concrete Touch 9006; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Concrete Touch "9006"
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C7900621; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C7900621
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Concrete Touch 9006
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Concrete Touch 9006; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Concrete Touch 9006; Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Concrete Touch 9006; Typ-ID: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Concrete Touch 9006

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Denim Effect, Axalta Surfaces_ES:Alesta SD-ENERGY MANIFESTO-Denim Effect:209204
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Denim Effect
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt DENIM EFFECT; Hersteller: Axalta Coating Systems; Product Code: SD301C5015020; Typname: Alesta SD-ENERGY MANIFESTO-Denim Effect; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Denim Effect
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C5015020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C5015020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Denim Effect
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Denim Effect; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Denim Effect; Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Denim Effect; Typ-ID: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Denim Effect

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Digital Red, Axalta Surfaces_ES:Alesta SD-ENERGY MANIFESTO-Digital Red:209205
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Digital Red
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt DIGITAL RED; Hersteller: Axalta Coating Systems; Product Code: SD301C3012020; Typname: Alesta SD-ENERGY MANIFESTO-Digital Red; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Digital Red
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C3012020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C3012020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Digital Red
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Digital Red; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Digital Red; Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Digital Red; Typ-ID: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Digital Red

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Electric dream, Axalta Surfaces_ES:Alesta SD-ENERGY MANIFESTO-Electric dream:209250
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Electric dream
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt ELECTRIC DREAM; Hersteller: Axalta Coating Systems; Product Code: SD301C5016020; Typname: Alesta SD-ENERGY MANIFESTO-Electric dream; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Electric dream
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C5016020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C5016020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Electric dream
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Electric dream; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Electric dream; Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Electric dream; Typ-ID: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Electric dream

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Groovy Red, Axalta Surfaces_ES:Alesta SD-ENERGY MANIFESTO-Groovy Red:209251
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Groovy Red
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt GROOVY RED; Hersteller: Axalta Coating Systems; Product Code: SD301C3013020; Typname: Alesta SD-ENERGY MANIFESTO-Groovy Red; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Groovy Red
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C3013020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C3013020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Groovy Red
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Groovy Red; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Groovy Red; Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Groovy Red; Typ-ID: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Groovy Red

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Intense Carbon, Axalta Surfaces_ES:Alesta SD-ENERGY MANIFESTO-Intense Carbon:209263
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Intense Carbon
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Matt INTENSE CARBON; Hersteller: Axalta Coating Systems; Product Code: SD301C4014020; Typname: Alesta SD-ENERGY MANIFESTO-Intense Carbon; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Intense Carbon
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Mate Liso; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD301C4014020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD301C4014020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Intense Carbon
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Intense Carbon; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Intense Carbon; Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Intense Carbon; Typ-ID: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Intense Carbon

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine, Axalta Surfaces_ES:Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine:209252
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture KINETIC TANGERINE; Hersteller: Axalta Coating Systems; Product Code: SD130C2011020; Typname: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD130C2011020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD130C2011020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine; Familie und Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine; Typ: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine; Typ-ID: Axalta Surfaces_ES: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine

# IfcBuildingElementProxy: Alesta SD-SuperDurable-Metallic Asphalt, Axalta Surfaces_ES:Alesta SD-SuperDurable-Metallic Asphalt:209253
In: Level 1
Type - Material: Alesta SD-SuperDurable-Metallic Asphalt
Type - Daten - Certificates: Superdurable Architectural powders are Qualicoat Class 2 and GSB Master approved.; Description: Superdurable poliéster arquitectura. Productos formulados especialmente para aplicaciones sobre aluminio y acero. Tienen muy buenas propiedades mecánicas y una resistencia a la intemperie superior.
Type - ID-Daten - (Type) Name: SD Fine Texture METALLIC ASPHALT; Hersteller: Axalta Coating Systems; Product Code: SD031C4020020; Typname: Alesta SD-SuperDurable-Metallic Asphalt; URL: http://www.axaltacs.com/es/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-SuperDurable-Metallic Asphalt
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_ES
Type - Text - Class: Surfaces; Model: Texturado Fino; Product available in: EMEA; Product Contact Email: alesta.barcelona@axaltacs.com; Product Contact Number: +34 9 36 10 60 20 / 23; Product URL: http://www.axaltacs.com/es/iconica; Reference Code: SD031C4020020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=es&country=es&gmc=SD031C4020020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-SuperDurable-Metallic Asphalt
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
