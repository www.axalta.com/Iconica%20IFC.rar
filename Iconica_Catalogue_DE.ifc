Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Denim Effect, Axalta Surfaces_DE:Alesta SD-ENERGY MANIFESTO-Denim Effect:197325
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Denim Effect; Familie und Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Denim Effect; Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Denim Effect; Typ-ID: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Denim Effect

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Digital Red, Axalta Surfaces_DE:Alesta SD-ENERGY MANIFESTO-Digital Red:197326
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Digital Red
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt DIGITAL RED; Hersteller: Axalta Coating Systems; Product Code: SD301C3012020; Typname: Alesta SD-ENERGY MANIFESTO-Digital Red; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Digital Red
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C3012020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C3012020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Digital Red
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Digital Red; Familie und Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Digital Red; Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Digital Red; Typ-ID: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Digital Red

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Electric dream, Axalta Surfaces_DE:Alesta SD-ENERGY MANIFESTO-Electric dream:197327
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Electric dream
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt ELECTRIC DREAM; Hersteller: Axalta Coating Systems; Product Code: SD301C5016020; Typname: Alesta SD-ENERGY MANIFESTO-Electric dream; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Electric dream
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C5016020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C5016020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Electric dream
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Electric dream; Familie und Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Electric dream; Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Electric dream; Typ-ID: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Electric dream

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Groovy Red, Axalta Surfaces_DE:Alesta SD-ENERGY MANIFESTO-Groovy Red:197328
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Groovy Red
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt GROOVY RED; Hersteller: Axalta Coating Systems; Product Code: SD301C3013020; Typname: Alesta SD-ENERGY MANIFESTO-Groovy Red; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Groovy Red
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C3013020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C3013020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Groovy Red
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Groovy Red; Familie und Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Groovy Red; Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Groovy Red; Typ-ID: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Groovy Red

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Intense Carbon, Axalta Surfaces_DE:Alesta SD-ENERGY MANIFESTO-Intense Carbon:197336
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Intense Carbon
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt INTENSE CARBON; Hersteller: Axalta Coating Systems; Product Code: SD301C4014020; Typname: Alesta SD-ENERGY MANIFESTO-Intense Carbon; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Intense Carbon
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C4014020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C4014020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Intense Carbon
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Intense Carbon; Familie und Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Intense Carbon; Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Intense Carbon; Typ-ID: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Intense Carbon

# IfcBuildingElementProxy: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine, Axalta Surfaces_DE:Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine:197337
In: Level 1
Type - Material: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Fine Texture KINETIC TANGERINE; Hersteller: Axalta Coating Systems; Product Code: SD130C2011020; Typname: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Feinstruktur; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD130C2011020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD130C2011020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine; Familie und Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine; Typ: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine; Typ-ID: Axalta Surfaces_DE: Alesta SD-ENERGY MANIFESTO-Kinetic Tangerine

# IfcBuildingElementProxy: Alesta SD-SuperDurable-Metallic Asphalt, Axalta Surfaces_DE:Alesta SD-SuperDurable-Metallic Asphalt:197339
In: Level 1
Type - Material: Alesta SD-SuperDurable-Metallic Asphalt
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Fine Texture METALLIC ASPHALT; Hersteller: Axalta Coating Systems; Product Code: SD031C4020020; Typname: Alesta SD-SuperDurable-Metallic Asphalt; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-SuperDurable-Metallic Asphalt
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Feinstruktur; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD031C4020020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD031C4020020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-SuperDurable-Metallic Asphalt
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-SuperDurable-Metallic Asphalt; Familie und Typ: Axalta Surfaces_DE: Alesta SD-SuperDurable-Metallic Asphalt; Typ: Axalta Surfaces_DE: Alesta SD-SuperDurable-Metallic Asphalt; Typ-ID: Axalta Surfaces_DE: Alesta SD-SuperDurable-Metallic Asphalt

# IfcBuildingElementProxy: Alesta SD-SuperDurable-Urban Cement, Axalta Surfaces_DE:Alesta SD-SuperDurable-Urban Cement:197340
In: Level 1
Type - Material: Alesta SD-SuperDurable-Urban Cement
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt URBAN CEMENT; Hersteller: Axalta Coating Systems; Product Code: SD301C7018020; Typname: Alesta SD-SuperDurable-Urban Cement; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-SuperDurable-Urban Cement
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C7018020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C7018020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-SuperDurable-Urban Cement
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-SuperDurable-Urban Cement; Familie und Typ: Axalta Surfaces_DE: Alesta SD-SuperDurable-Urban Cement; Typ: Axalta Surfaces_DE: Alesta SD-SuperDurable-Urban Cement; Typ-ID: Axalta Surfaces_DE: Alesta SD-SuperDurable-Urban Cement

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Anodised Silver, Axalta Surfaces_DE:Alesta SD-TECHNO PRECIOUS-Anodised Silver:197341
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Anodised Silver
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt ANODISED SILVER; Hersteller: Axalta Coating Systems; Product Code: SD201C7035020; Typname: Alesta SD-TECHNO PRECIOUS-Anodised Silver; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Anodised Silver
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD201C7035020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD201C7035020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Anodised Silver
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Anodised Silver; Familie und Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Anodised Silver; Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Anodised Silver; Typ-ID: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Anodised Silver

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Fine Pearl, Axalta Surfaces_DE:Alesta SD-TECHNO PRECIOUS-Fine Pearl:197342
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Fine Pearl
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt FINE PEARL; Hersteller: Axalta Coating Systems; Product Code: SD301C9034020; Typname: Alesta SD-TECHNO PRECIOUS-Fine Pearl; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Fine Pearl
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C9034020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C9034020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Fine Pearl
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Fine Pearl; Familie und Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Fine Pearl; Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Fine Pearl; Typ-ID: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Fine Pearl

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Gold Supreme, Axalta Surfaces_DE:Alesta SD-TECHNO PRECIOUS-Gold Supreme:197343
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Gold Supreme
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Fine Texture GOLD SUPREME; Hersteller: Axalta Coating Systems; Product Code: SD031C1033020; Typname: Alesta SD-TECHNO PRECIOUS-Gold Supreme; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Gold Supreme
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Feinstruktur; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD031C1033020; Series: SD Fine Texture; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD031C1033020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Gold Supreme
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Gold Supreme; Familie und Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Gold Supreme; Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Gold Supreme; Typ-ID: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Gold Supreme

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Grey Gold, Axalta Surfaces_DE:Alesta SD-TECHNO PRECIOUS-Grey Gold:197344
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Grey Gold
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt GREY GOLD; Hersteller: Axalta Coating Systems; Product Code: SD301C7031020; Typname: Alesta SD-TECHNO PRECIOUS-Grey Gold; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Grey Gold
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C7031020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C7031020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Grey Gold
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Grey Gold; Familie und Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Grey Gold; Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Grey Gold; Typ-ID: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Grey Gold

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Noble Bronze, Axalta Surfaces_DE:Alesta SD-TECHNO PRECIOUS-Noble Bronze:197352
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Noble Bronze
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt NOBLE BRONZE; Hersteller: Axalta Coating Systems; Product Code: SD301C8039020; Typname: Alesta SD-TECHNO PRECIOUS-Noble Bronze; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Noble Bronze
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C8039020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C8039020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Noble Bronze
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Noble Bronze; Familie und Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Noble Bronze; Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Noble Bronze; Typ-ID: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Noble Bronze

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Original Platinum, Axalta Surfaces_DE:Alesta SD-TECHNO PRECIOUS-Original Platinum:197353
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Original Platinum
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt ORIGINAL PLATINIUM; Hersteller: Axalta Coating Systems; Product Code: SD301C7037020; Typname: Alesta SD-TECHNO PRECIOUS-Original Platinum; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Original Platinum
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C7037020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C7037020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Original Platinum
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Original Platinum; Familie und Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Original Platinum; Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Original Platinum; Typ-ID: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Original Platinum

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Silver Dream, Axalta Surfaces_DE:Alesta SD-TECHNO PRECIOUS-Silver Dream:197355
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Silver Dream
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt SILVER DREAM; Hersteller: Axalta Coating Systems; Product Code: SD301C7036020; Typname: Alesta SD-TECHNO PRECIOUS-Silver Dream; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Silver Dream
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C7036020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C7036020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Silver Dream
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Silver Dream; Familie und Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Silver Dream; Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Silver Dream; Typ-ID: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Silver Dream

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Simply Copper, Axalta Surfaces_DE:Alesta SD-TECHNO PRECIOUS-Simply Copper:197356
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Simply Copper
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt SIMPLY COPPER; Hersteller: Axalta Coating Systems; Product Code: SD301C2040020; Typname: Alesta SD-TECHNO PRECIOUS-Simply Copper; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Simply Copper
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C2040020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C2040020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Simply Copper
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Simply Copper; Familie und Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Simply Copper; Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Simply Copper; Typ-ID: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Simply Copper

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Sunny Gold, Axalta Surfaces_DE:Alesta SD-TECHNO PRECIOUS-Sunny Gold:197357
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Sunny Gold
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Matt SUNNY GOLD; Hersteller: Axalta Coating Systems; Product Code: SD301C1032020; Typname: Alesta SD-TECHNO PRECIOUS-Sunny Gold; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Sunny Gold
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Matt Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD301C1032020; Series: SD Matt; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD301C1032020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Sunny Gold
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Ebene: Ebene: Level 1; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Sunny Gold; Familie und Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Sunny Gold; Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Sunny Gold; Typ-ID: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Sunny Gold

# IfcBuildingElementProxy: Alesta SD-TECHNO PRECIOUS-Techno Black, Axalta Surfaces_DE:Alesta SD-TECHNO PRECIOUS-Techno Black:197358
In: Level 1
Type - Material: Alesta SD-TECHNO PRECIOUS-Techno Black
Type - Daten - Certificates: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz. Die Produktlinie besitzt die Gütesiegel der Qualicoat Class 2 sowie GSB Master und erfüllt die Anforderungen der AAMA 2604.; Description: Superdurable Polyester Architectural ist ein Pulverlack auf Basis eines speziellen Polyesterharzes. Dieser wurde speziell für Anwendungen auf Aluminium und Stahl im Architekturbereich entwickelt. Er zeichnet sich besonders durch eine hervorragende Witterungsbeständigkeit aus und eignet sich daher insbesondere für den Außeneinsatz.
Type - ID-Daten - (Type) Name: SD Gloss TECHNO BLACK; Hersteller: Axalta Coating Systems; Product Code: SD801C4038020; Typname: Alesta SD-TECHNO PRECIOUS-Techno Black; URL: http://www.axaltacs.com/gb/iconica
Type - Materialien und Oberflächen - Surface Color: Alesta SD-TECHNO PRECIOUS-Techno Black
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Axalta Surfaces_DE
Type - Text - Class: Surfaces; Model: Glänzend Glatt; Product available in: EMEA; Product Contact Email: contact-cs@axaltacs.com; Product Contact Number: +49 87 03 93 18 10 63; Product URL: http://www.axaltacs.com/gb/iconica; Reference Code: SD801C4038020; Series: SD Gloss; Technical Information: http://sdstds.pow.dcicolor.info/checker.mvc?lvl=AxaltaSdsTdsAccess&user=Magento&company=Webshop&SheetType=tds&lang=de&country=de&gmc= SD801C4038020
Pset_BuildingElementProxyCommon - Reference: Alesta SD-TECHNO PRECIOUS-Techno Black
Pset_ManufacturerTypeInformation - Manufacturer: Axalta Coating Systems
Abhängigkeiten - Ebene: Ebene: Level 1; Versatz: 0 mm; Verschieben mit umliegenden Elementen: no; Basisbauteil: Ebene : Level 1
Abmessungen - Fläche: 0.542005 m2; Volumen: 0.00615693 m3
Phasen - Phase erstellt: New Construction
Sonstige - Familie: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Techno Black; Familie und Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Techno Black; Typ: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Techno Black; Typ-ID: Axalta Surfaces_DE: Alesta SD-TECHNO PRECIOUS-Techno Black

# IfcBuildingElementProxy: Modelltext:600mm Arial
In: Level 1
Text - Fett: no; Kursiv: no; Schriftart: Arial; Textgröße: 600 mm
Sonstige - Kategorie: Allgemeines Modell; Familienname: Modelltext; Familie: Modelltext: 600mm Arial; Familie und Typ: Modelltext: 600mm Arial; Typ: Modelltext: 600mm Arial; Typ-ID: Modelltext: 600mm Arial
ID-Daten - Typname: 600mm Arial; Unterkategorie: Allgemeines Modell
Pset_BuildingElementProxyCommon - Reference: 600mm Arial
Abhängigkeiten - Arbeitsebene: Ebene : Level 1
Abmessungen - Tiefe: 150 mm
Grafiken - Horizontale Ausrichtung: Links; Text: Axalta metal surfaces
Phasen - Phase erstellt: New Construction
